# Keil uVision project PG-FP6-CONTROLLER.uvprojx, settings and files
target RENESAS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC240VE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: PG-FP6-CONTROLLER
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC230_240\Include;..\Library\StdDriver\inc;..\PGFP6_v1.1_autoLoad
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group USER
    ./: main.c user.c user.h PGFP6.h Init.c Init.h Interrupt.c PG_FP6.c
  group LIBRARY
    ../Library/StdDriver/src/: clk.c fmc.c gpio.c sys.c timer.c uart.c
  group Modbus
    ./: PetitModbus.c PetitModbus.h PetitModbusPort.c PetitModbusPort.h PetitRegConstant.c
